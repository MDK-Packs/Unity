# Keil uVision project example_2.uvprojx, settings and files
target Simulation (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: example_2
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=1
  c include: ..\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Documentation
    ../: readme.txt
  group Source Files
    ../src/: ProductionCode.c ProductionCode2.c
    ../test/: TestProductionCode.c TestProductionCode2.c
    ../test/test_runners/: TestProductionCode_Runner.c TestProductionCode2_Runner.c all_tests.c
    ./: sys_command.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.2.0, Test:Unity 2.5.0, Compiler:I/O:STDOUT 1.2.0
